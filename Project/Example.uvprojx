# Keil uVision project Example.uvprojx, settings and files
target projectMau (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project_LedDon +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM3210X_MD
  c include: ..\Lib;..\Lib\STM32F10x_StdPeriph_Driver\inc;..\Lib\CMSIS\CM3\CoreSupport;.\Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group lib
    ../Lib/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c
    ../Lib/: timers.c timers.h pid.h pid.c control.c control.h motor_tb6612.c motor_tb6612.h adc_dma.c line_sensors.c line_sensors.h line_params.h system_state.h system_state.c button.c button.h
    ../../DoLine/Lib/: board.h
  group user
    ../User/: main.c
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.0
